# Keil uVision project XRLite.uvproj, settings and files
target XRLite (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: XRLite +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\include;.\StdDriver\inc;.\Hardware
  group User
    ./: STARTUP_CMS8S6990.A51 main.c
  group Stdlib
    ./StdDriver/src/: gpio.c
  group Hardware
    ./Hardware/: PinDefs.h ADCCfg.c delay.c NTC.c SideKey.c LEDMgmt.c PWM.c OutputChannel.c Flash.c TailKey.c
  group Logic
    ./Logic/: BattVoltDisplay.c TempControl.c Sleep.c ModeControl.c RampConfig.c SelfTest.c TailMemory.c Strap.c SOS.c LowVoltageProt.c SpecialMode.c
